# IAR project firmware.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CM4F; STM32F407xx; ARM_ADS
  ICCARM.CCDiagSuppress: Pe301,Pa050
  ICCARM.CCIncludePath2: ..\..\..\inc; ..\..\..\src; ..\..\..\cfg; ..\..\..\ext\diOS; ..\..\..\ext\diOS\inc; ..\..\..\ext\diOS\src; ..\..\..\ext\diOS\cfg; ..\..\..\ext\diOS\ext; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\ext\diOS\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\ext\diOS\ext\freertos\800\Source\include; ..\..\..\ext\diOS\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\ext\diOS\cfg\freertos\800; ..\..\..\ext\diOS\ext\fat_fs\0.10b\src; ..\..\..\ext\diOS\cfg\fat_fs\0.10b; ..\..\..\ext\diOS\src\hal; ..\..\..\ext\diOS\src\hal\bsp; ..\..\..\ext\diOS\src\hal\csp\stm32f40xx; ..\..\..\ext\diOS\src\hal\bsp\olimex_stm32_p407; ..\..\..\ext\diOS\src\tst; ..\..\..\ext\diOS\cfg\olimex_stm32_p407; ..\..\..\ext\mp3\helix\pub; ..\..\..\ext\mp3\helix\real
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_flash_d.bin
  prebuild: ..\..\..\ext\diOS\tls\revision_update.bat ..\..\..\src
  postbuild: xcopy /y "Debug FLASH\Exe\*.bin" ..\..\..\bin
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_flash_d.out
  ILINK.IlinkIcfFile: ..\..\..\ext\diOS\src\hal\bsp\olimex_stm32_p407\olimex_stm32_p407_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release FLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\ext\target\freertos\800\Source\include; ..\..\..\ext\target\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\ext\target\csp\cm4\CMSIS\400\Include; ..\..\..\ext\target\csp\cm4\CMSIS\400\Device\ST\STM32F4xx\Include; ..\..\..\ext\target\csp\stm32f4xx\STM32F4xx_StdPeriph_Driver\110\inc; ..\..\..\inc; ..\..\..\src\target\app; ..\..\..\src\target\hal\bsp\olimex_stm32_p407; ..\..\..\cfg\target; ..\..\..\cfg\target\freertos\800\cm4f; ..\..\..\cfg\target\olimex_stm32_p407
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_flash.bin
  prebuild: ..\..\..\tls\revision_update.bat ..\..\..\src\target
  postbuild: xcopy /y "Release FLASH\Exe\*.bin" ..\..\..\bin\target
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_d.out
  ILINK.IlinkIcfFile: ..\..\..\cfg\target\olimex_stm32_p407\olimex_stm32_p407_flash.icf
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\..\inc; ..\..\..\src; ..\..\..\ext\diOS\inc; ..\..\..\ext\diOS\src; ..\..\..\ext\diOS\cfg; ..\..\..\ext\diOS\ext; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\ext\diOS\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\ext\diOS\ext\freertos\800\Source\include; ..\..\..\ext\diOS\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\ext\diOS\cfg\freertos\800\cm4f; ..\..\..\ext\diOS\ext\fat_fs\0.10b\src; ..\..\..\ext\diOS\cfg\fat_fs\0.10b\cm4f; ..\..\..\ext\diOS\src\hal\csp\stm32f40xx; ..\..\..\ext\diOS\src\tst; ..\..\..\ext\diOS\cfg\olimex_stm32_p407
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_sram_d.bin
  postbuild: xcopy /y "Debug SRAM\Exe\*.bin" ..\..\..\bin
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_sram_d.out
  ILINK.IlinkIcfFile: ..\..\..\ext\diOS\cfg\olimex_stm32_p407\olimex_stm32_p407_sram.icf
configuration Release SRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_sram.bin
  prebuild: as above
  postbuild: xcopy /y "Release SRAM\Exe\*.bin" ..\..\..\bin\target
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_d.out
  ILINK.IlinkIcfFile: ..\..\..\cfg\target\olimex_stm32_p407\olimex_stm32_p407_sram.icf
  group (top)
    ../../../src/: main.c
  group app
    ../../../src/: os_shell_commands_app.c task_a_ko.c task_b_ko.c task_mmplay.c task_netserv.c
  group app/audio
    ../../../src/: audio_codec.c audio_codec_mp3.c audio_codec_wav.c
  group app/audio/mp3/helix
    ../../../ext/mp3/helix/real/arm/: asmpoly_thumb2_iar.s
    ../../../ext/mp3/helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../../ext/mp3/helix/: mp3dec.c mp3tabs.c
  group lib_d
    ../../../ext/diOS/lib/iar740/: cm4f_osal_d.a cm4f_rtos_d.a olimex_stm32_p407_flash_hal_d.a olimex_stm32_p407_sram_hal_d.a
