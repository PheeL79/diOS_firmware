# IAR project firmware.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CM4F
  ICCARM.CCIncludePath2: ..\..\..\inc; ..\..\..\src; ..\..\..\ext\diOS\inc; ..\..\..\ext\diOS\src; ..\..\..\ext\diOS\cfg; ..\..\..\ext\diOS\ext; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\400\CMSIS\Include; ..\..\..\ext\diOS\ext\csp\cm4\CMSIS\400\Device\ST\STM32F4xx\Include; ..\..\..\ext\diOS\ext\csp\stm32f4xx\STM32_USB-Host-Device_Lib\210\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\ext\diOS\ext\freertos\800\Source\include; ..\..\..\ext\diOS\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\ext\diOS\cfg\freertos\800\cm4f; ..\..\..\ext\diOS\ext\fat_fs\0.10a\src; ..\..\..\ext\diOS\cfg\fat_fs\0.10a\cm4f; ..\..\..\ext\diOS\src\hal\csp\stm32f40xx; ..\..\..\ext\diOS\src\tst
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_flash_d.bin
  prebuild: ..\..\..\ext\diOS\tls\revision_update.bat ..\..\..\src\target
  postbuild: xcopy /y "Debug FLASH\Exe\*.bin" ..\..\..\bin
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_flash_d.out
  ILINK.IlinkIcfFile: ..\..\..\ext\diOS\cfg\olimex_stm32_p407\olimex_stm32_p407_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release FLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\ext\target\freertos\800\Source\include; ..\..\..\ext\target\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\ext\target\csp\cm4\CMSIS\400\Include; ..\..\..\ext\target\csp\cm4\CMSIS\400\Device\ST\STM32F4xx\Include; ..\..\..\ext\target\csp\stm32f4xx\STM32F4xx_StdPeriph_Driver\110\inc; ..\..\..\inc; ..\..\..\src\target\app; ..\..\..\src\target\hal\bsp\olimex_stm32_p407; ..\..\..\cfg\target; ..\..\..\cfg\target\freertos\800\cm4f; ..\..\..\cfg\target\olimex_stm32_p407
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_flash.bin
  prebuild: ..\..\..\tls\revision_update.bat ..\..\..\src\target
  postbuild: xcopy /y "Release FLASH\Exe\*.bin" ..\..\..\bin\target
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_d.out
  ILINK.IlinkIcfFile: ..\..\..\cfg\target\olimex_stm32_p407\olimex_stm32_p407_flash.icf
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_sram_d.bin
  prebuild: ..\..\..\ext\diOS\tls\revision_update.bat ..\..\..\src
  postbuild: xcopy /y "Debug SRAM\Exe\*.bin" ..\..\..\bin
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_sram_d.out
  ILINK.IlinkIcfFile: ..\..\..\ext\diOS\cfg\olimex_stm32_p407\olimex_stm32_p407_sram.icf
configuration Release SRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: firmware_olimex_stm32_p407_sram.bin
  prebuild: as above
  postbuild: xcopy /y "Release SRAM\Exe\*.bin" ..\..\..\bin\target
  ILINK.IlinkOutputFile: firmware_olimex_stm32_p407_d.out
  ILINK.IlinkIcfFile: ..\..\..\cfg\target\olimex_stm32_p407\olimex_stm32_p407_sram.icf
  group (top)
    ../../../src/: main.c
  group app
    ../../../src/: os_shell_commands_app.c task_a_ko.c task_b_ko.c
  group lib_d
    ../../../ext/diOS/lib/iar710/: cm4f_osal_d.a cm4f_rtos_d.a olimex_stm32_p407_flash_hal_d.a olimex_stm32_p407_sram_hal_d.a
